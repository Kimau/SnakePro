# IAR project XBeeTest.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl4tptinl8n.h
  General.OGChipSelectEditMenu: LPC2106 NXP LPC2106
  ICCARM.CCIncludePath2: 
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: at91_lnk_ram.xcl
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath: dl-stnl0.r79
  ICCARM.CCDefines: NDEBUG
  XLINK.XclFile: lnk0t.xcl
  group (top)
    ./: at91.c at91_cstartup.s79 at91_low_level_init.c AT91PIO.c Delay.c GameCore.c keypad.c LCDFont.c main.c pg12864.c Sound.c timer.c uart.c XBee.c
